# IAR project IR_CAP_030.ewp, settings and files
configuration IR_CAP_030 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030F4 ST STM32F030F4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F030x6
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F0xx_HAL_Driver/Inc; ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F0xx/Include; ../Drivers/CMSIS/Include; ..\UserFile\Dispaly
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: IR_CAP_030.hex
  ILINK.IlinkOutputFile: IR_CAP_030.out
  ILINK.IlinkIcfFile: stm32f030x6_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration IR_Cap030_Out (ARM, debug)
  as the first configuration, except:
configuration IR_030Release (ARM)
  as the first configuration, except:
  group Application/EWARM
    ./: startup_stm32f030x6.s
  group Application/User
    ../Src/: gpio.c main.c stm32f0xx_hal_msp.c stm32f0xx_it.c stm32f1xx_hal_tim_user.c tim.c
  group Display
    ../UserFile/Dispaly/: Display.c display.h DisplayDrive.c DisplayDrive.h
  group Display/DisSataic
    ../UserFile/Dispaly/: DisplayDriveStatic.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_tim.c
                
                    IR_CAP_030 stm32f0xx_hal_tim_ex.c
